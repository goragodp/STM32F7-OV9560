# IAR project STM32F7-OV9560.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F765VI ST STM32F765VI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F765xx
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Driver\CMSIS\Include; ..\..\..\Driver\STM32F7xx_HAL_Driver\Inc; ..\..\..\Driver\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\Third Party\OV9650
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F7-OV9560.srec
  ILINK.IlinkOutputFile: STM32F7-OV9560.out
  ILINK.IlinkIcfFile: C:\Users\Goragod\Desktop\STM32F7-OV9560\Project\STM32F765VI\EWARM\stm32f756xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ./: startup_stm32f756xx.s
    ../src/: system_stm32f7xx.c
  group Driver/HAL_Driver/header
    ../../../Driver/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_cortex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_def.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_gpio.h stm32f7xx_hal_i2c.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_usart.h
  group Driver/HAL_Driver/source
    ../../../Driver/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_usart.c
  group OV9650
    ../../../../openmv/src/omv/boards/OPENMV3/: omv_boardconfig.h
    ../../../../openmv/src/omv/: ov9650.c ov9650.h ov9650_regs.h
    ../../../Third Party/OV9650/: sccb.c sccb.h
  group User
    ../src/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
