# IAR project STM32F7-OV9650.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F765VI ST STM32F765VI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F765xx; ARM_MATH_CM7; __FPU_PRESENT
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Driver\CMSIS\Include; ..\..\..\Driver\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\Driver\STM32F7xx_HAL_Driver\Inc; ..\..\..\Third Party\omv; ..\..\..\Third Party\omv\boards\OPENMV3; ..\..\..\Third Party\omv\img; ..\..\..\Third Party\fatfs\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM32F7-OV9650.out
  ILINK.IlinkIcfFile: C:\Users\Goragod\Desktop\STM32F7-OV9560\Project\STM32F765VI\EWARM\stm32f756xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../Driver/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f765xx.s
  group CMSIS
    ./: stm32f756xx_flash.icf
    ../src/: system_stm32f7xx.c
  group Driver/Include
    ../../../Driver/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_cortex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dsi.h stm32f7xx_hal_gpio.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_rcc.h
  group Driver/Source
    ../../../Driver/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c
  group fatfs
    ../../../Third Party/fatfs/src/: ff.c
  group OMV
    ../../../Third Party/omv/: ov9650.c sccb.c sensor.c
  group User
    ../src/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
    ../inc/: stm32fxxx_hal_msp.c
